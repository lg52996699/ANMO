# Keil uVision project UART1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: UART1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c USART1.C main.c EEPROM.c Plat.c tm1668.c timer.c ADC.c GPIO.c PCA.c
